FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

include ${FLAVOUR}.inc

