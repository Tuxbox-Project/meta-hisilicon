SRCDATE = "20200731"

SRC_URI[sha256sum] = "e7948ef3e71729efff46e251498ebcadd4f9399ede130e36f5ee8e50ea079316"

include hd-dvb-modules.inc

