SRCDATE = "20190201"

require hd-bootargs.inc

COMPATIBLE_MACHINE = "hd60"

SRC_URI[md5sum] = "b891ce2daabe4231bb7376bdc6b2e716"
SRC_URI[sha256sum] = "66108f9815abc1dccc27440d4e6f5527b4dd58563200e3c5a35461f6314b5851"
