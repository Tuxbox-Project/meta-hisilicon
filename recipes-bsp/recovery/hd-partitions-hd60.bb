SRCDATE = "20200319"

require hd-partitions.inc

SRC_URI[sha256sum] = "0a87c7a9708bd801f2cecedb4799f39469dcbd83936dbed3b57dba7883efea0d"

COMPATIBLE_MACHINE = "hd60"
