SRCDATE = "20200504"

require hd-bootargs.inc

SRC_URI[sha256sum] = "5a6116bb361beea8e11168e3607be4c9d0e936a8f436f61a6fe6b0f08d1476de"

COMPATIBLE_MACHINE = "hd61"
